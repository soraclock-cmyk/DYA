## app/Kconfig
```kconfig
config ZMK_BEHAVIOR_OS_LAYER
    bool "OS Layer switching based on BLE profile"
    default n
```
